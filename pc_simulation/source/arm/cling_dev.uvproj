# Keil uVision project cling_dev.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: ClingWatch +hex
  c flags: Optim=4 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\Include;..\Include\s110;..\Include\app_common;..\Include\ble;..\Include\ble\ble_services;..\Include\sd_common
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x20000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../: arm_startup_nrf51.s system_nrf51.c
  group Source Code
    ./../: main.c
    ../: hal.c dbg.c system.c fs_fat.c fs_file.c fs_nflash_rw.c fs_root.c user.c RTC.c Watchdog.c base.c pedometer.c btle.c twi_hw_master.c Aes.c sensor.c ui.c sysclk.c interrupt.c uart.c gpio.c spi_master.c lis3dh.c oled.c batt.c nflash_spi.c fs_flash.c sysflash_rw.c hssp.c issp_driver_routines.c issp_routines.c touch.c ppg.c ancs.c butterworth.c thermistor.c sim.c link.c cp.c weather.c tracking.c ota.c sleep.c reminder.c notific.c
  group Services
    ../Source/ble/ble_services/: ble_srv_common.c ble_dis.c ble_bas.c ble_hrs.c
  group Libraries
    ../Source/ble/: ble_error_log.c ble_advdata.c ble_sensorsim.c ble_conn_params.c ble_bondmngr.c ble_flash.c ble_radio_notification.c ble_debug_assert_handler.c
  group app_common
    ../Source/app_common/: app_timer.c pstorage.c crc16.c
  group nrf_delay
    ../Source/nrf_delay/: nrf_delay.c
  group simple_uart
    ../Source/simple_uart/: simple_uart.c
  group sd_common
    ../Source/sd_common/: softdevice_handler.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: cling_dev +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
